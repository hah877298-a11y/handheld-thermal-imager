# Keil uVision project ThermalImager.uvprojx, settings and files
target ThermalImager (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ThermalImager +hex
  c flags: Optim=2 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\MLX90640;..\HARDWARE\INTERP;..\HARDWARE\PALETTE;..\HARDWARE\TRACK;..\HARDWARE\BEEP;..\HARDWARE\SDIO;..\HARDWARE\FATFS;..\HARDWARE\BMP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/MLX90640/: mlx90640.c
    ../HARDWARE/PALETTE/: palette.c
    ../HARDWARE/INTERP/: interp.c
    ../HARDWARE/TRACK/: track.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/FATFS/: ff.c diskio.c
    ../HARDWARE/BMP/: bmp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c
  group README
    ../: README.TXT
